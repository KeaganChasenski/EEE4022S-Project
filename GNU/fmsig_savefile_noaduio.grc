options:
  parameters:
    author: Keagan Chasenski
    generate_options: no_gui
    id: fmsig_savefile_noaudio
    output_language: python
    title: Direction Finding - Read FM signal to file
  states: {}

blocks:
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/pi/Desktop/Thesis/Testing/a2_data.iq
    type: complex
    vlen: '2'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/pi/Desktop/Thesis/Testing/a1_data.iq
    type: complex
    vlen: '2'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    alias: vector_stream_antenna2
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    alias: vector_stream_antenna1
    type: complex
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 2e6
    analog_bandw_ch1: 2e6
    ch_align: 'False'
    channel_mode: '2'
    digital_bandw_ch0: 2e6
    digital_bandw_ch1: 2e6
    filename: /home/pi/Desktop/Thesis/Testing/rf
    gain_dB_ch0: '45'
    gain_dB_ch1: '45'
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: 150e6
    samp_rate: 20e6
    serial: 000907060246091F
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_file_sink_0_0, '0']
- [limesdr_source_0, '0', blocks_stream_to_vector_0_0, '0']
- [limesdr_source_0, '1', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
